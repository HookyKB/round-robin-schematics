File: round-robin-11-90.kicad_sch (KiCad schematic)
At the start: 200 parts

Commit message: Add missing connector on DS1
Connections:
- net IO 1: now also DS1.1 (K)
