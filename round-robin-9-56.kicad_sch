File: round-robin-9-56.kicad_sch (KiCad schematic)
At the start: 128 parts

Commit message: Add missing connector on DS1
Connections:
- net IO 1: now also DS1.1 (K)
