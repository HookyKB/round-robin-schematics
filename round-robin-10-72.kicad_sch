File: round-robin-10-72.kicad_sch (KiCad schematic)
At the start: 162 parts

Commit message: Add missing connector on DS1
Connections:
- net IO 1: now also DS1.1 (K)
